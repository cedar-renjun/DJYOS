# Keil uVision project keil�����ڵ���.uvproj, settings and files
target STM32F103ZE (ARM-GNU)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: qh_1_tiny.elf
  group src_bsp_arch_core
    ../../djyos/bsp/arch/arm/cortex_m/cortex_m3/core/: cpu.c cpus.S exception.c exceptions.S int_hard.c ints.S
  group src_bsp_arch_startup
    ../../djyos/bsp/arch/arm/cortex_m/cortex_m3/startup/stm32/: SRAM.c initcpuc.c
  group src_bsp_board_peripheral_LCD_9325
    ../../djyos/bsp/board_peripheral/qh_1/LCD_9325/: LCD_9325.c
  group src_bsp_board_peripheral_STMPE811
    ../../djyos/bsp/board_peripheral/qh_1/STMPE811/: I2C_STM32.c TS_I2C.c stmpe811.c
  group src_bsp_board_peripheral_ds18b20
    ../../djyos/bsp/board_peripheral/qh_1/ds18b20/: DS18B20.c
  group src_bsp_board_peripheral_keyboard
    ../../djyos/bsp/board_peripheral/qh_1/keyboard/: key_hard.c
  group src_bsp_board_peripheral_nandflash
    ../../djyos/bsp/board_peripheral/qh_1/nandflash/: k9f1208xxx.c
  group src_bsp_cpu_peripheral_src
    ../../djyos/bsp/cpu_peripheral/stm32/src/: cpu_peri.c dma.c gpio.c stm32_ad.c stm32_rtc.c stm32_wdt.c uart.c
  group src_bsp_vendor_lib_CMSIS_CoreSupport
    ../../djyos/bsp/vendor_lib/CMSIS/CM3/CoreSupport/: core_cm3.c
  group src_bsp_vendor_lib_stm32
    ../../djyos/bsp/vendor_lib/stm32/: stm32f10x_it.c
  group src_bsp_vendor_lib_stm32_STM32F10x_StdPeriph_Driver_src
    ../../djyos/bsp/vendor_lib/stm32/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c system_stm32f10x.c
  group src_djyos_buffer
    ../../djyos/djyos/buffer/: line.c ring.c
  group src_djyos_clock
    ../../djyos/djyos/clock/: clock.c
  group src_djyos_core
    ../../djyos/djyos/core/: djyos.c endian.c sys_init.c
  group src_djyos_djyfs
    ../../djyos/djyos/djyfs/: file.c
  group src_djyos_djyfs_fat
    ../../djyos/djyos/djyfs/fat/: djyFAT32.c
  group src_djyos_djyfs_flashfile
    ../../djyos/djyos/djyfs/flashfile/: ddr.c ecc256.c fdt.c flashfile.c mdr.c
  group src_djyos_djyip
    ../../djyos/djyos/djyip/: arp.c enet.c enet_cmd.c ethernet.c icmp.c ip.c ipopts.c ping.c socket.c socketopts.c tcp.c tcpopts.c udp.c
  group src_djyos_driver
    ../../djyos/djyos/driver/: driver.c
  group src_djyos_gui_display
    ../../djyos/djyos/gui/display/: gk_display.c
  group src_djyos_gui_encoding
    ../../djyos/djyos/gui/encoding/: ascii.c encoding.c gb2312.c loc_string.c nls.c utf8.c
  group src_djyos_gui_font
    ../../djyos/djyos/gui/font/: ascii8x16.c ascii8x8.c font.c gb2312_16.c textshow.c
  group src_djyos_gui_gk_draw
    ../../djyos/djyos/gui/gk_draw/: gk_draw.c
  group src_djyos_gui_lib
    ../../djyos/djyos/gui/lib/: gk_api.c
  group src_djyos_gui_window
    ../../djyos/djyos/gui/window/: gk_clip.c gk_win.c
  group src_djyos_int
    ../../djyos/djyos/int/: int.c
  group src_djyos_lock
    ../../djyos/djyos/lock/: lock.c
  group src_djyos_memory
    ../../djyos/djyos/memory/: memb.c mems.c
  group src_djyos_msg
    ../../djyos/djyos/msg/: msg.c
  group src_djyos_pipe
    ../../djyos/djyos/pipe/: pipe.c
  group src_djyos_rsc
    ../../djyos/djyos/rsc/: rsc.c
  group src_djyos_shell
    ../../djyos/djyos/shell/: shell.c shell_fs.c
  group src_djyos_stdin
    ../../djyos/djyos/stdin/: stdin_dev.c
  group src_djyos_stdin_keypad
    ../../djyos/djyos/stdin/keypad/: key.c
  group src_djyos_stdin_touch
    ../../djyos/djyos/stdin/touch/: Touch.c
  group src_djyos_wdt
    ../../djyos/djyos/wdt/: wdt.c
  group src_loader_si
    ../../djyos/loader/si/: loader.c pre_loader.c
  group src_user_config
    ./src/user/config/: module_init.c
  group src_user_critical
    ./src/user/critical/: critical.c
  group src_user_src
    ./src/user/src/: LED.c main.c
