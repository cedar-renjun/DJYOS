# Keil uVision project KeilDebug.uvproj, settings and files
target KeilDebug (ARM-ADS)
  device: S3C2440A Samsung
  cpu: IRAM(0x40000000-0x40000FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: tq2440.elf
  c flags: Optim=1
  memory RVCT1: ROM 0x30100000 size 0x10000
  memory RVCT9: RAM 0x40000000 size 0x1000
  group bsp_arch_core
    ../../../djyos/bsp/arch/arm/arm7_11/arm9/samsung/s3c2440/core/: cpu.c int_hard.c ints.S
    ../../../djyos/bsp/arch/arm/arm7_11/common/: cache.c cpus.S exception.c exceptions.S mmu.c mmucache.S ReadMe.TXT
  group bsp_arch_startup
    ../../../djyos/bsp/arch/arm/arm7_11/arm9/samsung/s3c2440/startup/: initcpu.S initcpuc.c
  group bsp_board_peripheral
    ../../../djyos/bsp/board_peripheral/tq2440/keypad/: key_hard.c
    ../../../djyos/bsp/board_peripheral/tq2440/lcd/: lcddrv.c
    ../../../djyos/bsp/board_peripheral/tq2440/nandflash/: k9f1208xxx.c k9fxxx.c
  group bsp_cpu_perpheral
    ../../../djyos/bsp/cpu_peripheral/samsung/s3c2440/src/: cpu_peri.c gpio.c nude_io.c rtc.c sdi.c timer.c uart.c wdt_hard.c
  group djyos_misc
    ../../../djyos/djyos/buffer/: line.c ring.c
    ../../../djyos/djyos/clock/: clock.c
    ../../../djyos/djyos/core/: djyos.c endian.c sys_init.c
    ../../../djyos/djyos/driver/: driver.c
    ../../../djyos/djyos/int/: int.c
    ../../../djyos/djyos/lock/: lock.c
    ../../../djyos/djyos/memory/: memb.c mems.c
    ../../../djyos/djyos/msg/: msg.c
    ../../../djyos/djyos/pipe/: pipe.c
    ../../../djyos/djyos/rsc/: rsc.c
    ../../../djyos/djyos/shell/: shell.c shell_fs.c
    ../../../djyos/djyos/stdin/: stdin_dev.c
    ../../../djyos/djyos/stdin/char_term/: char_term.c
    ../../../djyos/djyos/stdin/keypad/: key.c
    ../../../djyos/djyos/stdin/touch/: Touch.c
    ../../../djyos/djyos/wdt/: wdt.c
  group djyos_djyfs
    ../../../djyos/djyos/djyfs/fat/: djyFAT32.c
    ../../../djyos/djyos/djyfs/flashfile/: ddr.c ecc256.c fdt.c flashfile.c mdr.c
    ../../../djyos/djyos/djyfs/: file.c
  group djyos_djyip
    ../../../djyos/djyos/djyip/: arp.c enet.c enet_cmd.c ethernet.c icmp.c ip.c ipopts.c ping.c socket.c socketopts.c tcp.c tcpopts.c udp.c
  group djyos_djygui
    ../../../djyos/djyos/gui/display/: gk_display.c
    ../../../djyos/djyos/gui/encoding/: ascii.c ascii.h encoding.c encoding.h gb2312.c gb2312.h loc_string.c loc_string.h nls.c nls.h utf8.c utf8.h
    ../../../djyos/djyos/gui/font/: ascii8x8.c ascii8x8.h ascii8x16.c ascii8x16.h font.c font.h gb2312_16.c gb2312_16.h textshow.c
    ../../../djyos/djyos/gui/gk_draw/: gk_draw.c
    ../../../djyos/djyos/gui/lib/: gk_api.c
    ../../../djyos/djyos/gui/window/: gk_clip.c gk_win.c
  group loader
    ../../../djyos/loader/si/: copy_table.h loader.c pre_loader.c
  group user
    ../src/user/src/: main.c
    ../src/user/critical/: critical.c
    ../src/user/config/: module_init.c
